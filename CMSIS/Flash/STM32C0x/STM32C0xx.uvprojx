# Keil uVision project STM32C0xx.uvprojx, settings and files
target STM32C0x_32 (6220000::V6.22::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: STM32C0x_32
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_MEM, STM32C0x_32
  c include: ..\..\..\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STM32C0x_16 (6220000::V6.22::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: STM32C0x_16
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FLASH_MEM, STM32C0x_16
  c include: ..\..\..\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32C0x_128 (6220000::V6.22::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: STM32C0x_128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3
  c define: FLASH_MEM, STM32C0x_128
  c include: ..\..\..\Drivers\CMSIS\Core\Include;..\STM32C0x
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32C0x_64 (6220000::V6.22::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: STM32C0x_64
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: FLASH_MEM, STM32C0x_64
  c include: ..\..\..\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32C0x_256 (6220000::V6.22::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: STM32C0x_256
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: FLASH_MEM, STM32C0x_256
  c include: ..\..\..\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
software components: CMSIS:CORE 6.1.0
